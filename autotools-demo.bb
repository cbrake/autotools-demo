# recipe to build the autotools-demo in the working tree

inherit srctree autotools gitver

PV = "${GITVER}"


